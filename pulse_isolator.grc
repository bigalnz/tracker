options:
  parameters:
    author: Derek Kozel
    comment: |-
      Heavily derived from Andy Walls' answer to
      https://dsp.stackexchange.com/questions/50103/checking-for-vhf-pulse-with-sdr-and-python
    generate_options: qt_gui
    id: wildlife_tracker
    output_language: python
    title: Wildlife Tracker
  states: {}

blocks:
- name: max_freq
  id: variable_qtgui_entry
  parameters:
    label: Max Tone Frequency
    type: real
    value: '2000'
  states: {}
- name: min_freq
  id: variable_qtgui_entry
  parameters:
    label: Min Tone Frequency
    type: real
    value: '1000'
  states: {}
- name: pulse_len
  id: variable_qtgui_range
  parameters:
    label: Pulse Length (samples)
    rangeType: int
    start: '1'
    step: '1'
    stop: '200'
    value: '156'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2.4e6)
  states: {}
- name: variable_qtgui_entry_0
  id: variable_qtgui_entry
  parameters:
    type: int
    value: '0'
  states: {}
- name: analog_pll_refout_cc_0
  id: analog_pll_refout_cc
  parameters:
    comment: |-
      Find the strongest tone
      and generate a clean version
    max_freq: max_freq*2*np.pi/samp_rate
    min_freq: min_freq*2*np.pi/samp_rate
    w: '0.35'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_moving_average_xx_0
  id: blocks_moving_average_xx
  parameters:
    length: pulse_len
    max_iter: '4000'
    scale: '1'
    type: complex
  states: {}
- name: blocks_multiply_conjugate_cc_0
  id: blocks_multiply_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_peak_detector2_fb_0
  id: blocks_peak_detector2_fb
  parameters:
    alpha: '0.001'
    look_ahead: '100'
    threshold_factor_rise: '1'
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    file: D:\baseband_160991830Hz_10-45-33_26-11-2023 Rotoroa.wav
    nchan: '2'
    repeat: 'True'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Embedded Python Blocks:

      Each time this file is saved, GRC will instantiate the first class it finds
      to get ports and parameters of your block. The arguments to __init__  will
      be the parameters. All of them are required to have default values!
      """

      import numpy as np
      from gnuradio import gr
      import pmt


      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Embedded Python Block example - a simple multiply const"""

          def __init__(self, threshold=0.9, report_period=128):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Interval_Tagger',   # will show up in GRC
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.threshold = threshold
              self.my_log = gr.logger(self.alias())
              self.timer = 0
              self.report_period = report_period
              self.readyForTag = True


          def work(self, input_items, output_items):

              for index in range(len(input_items[0])):
                  if input_items[0][index] > 0.95:
                      key = pmt.intern('index')
                      value = pmt.from_float(np.round(float(input_items[0][index]),2))
                      writeIndex = self.nitems_written(0) + index-1
                      #print(f"Index: {writeIndex}")
                      #print(f"Value: {value}")            
                      self.add_item_tag(0, writeIndex, key, value ) 

              output_items[0][:] = input_items[0]
              return len(output_items[0])
    alias: index
    report_period: '128'
    threshold: '0.5'
  states: {}
- name: epy_block_1
  id: epy_block
  parameters:
    _source_code: |-
      import numpy as np
      from gnuradio import gr
      import pmt

      class blk(gr.sync_block):

          def __init__(self, key_filter="index"):
              gr.sync_block.__init__(
                  self,
                  name="Tag Delta",
                  in_sig=[np.float32],
                  out_sig=[np.float32]
              )
              self.key_filter = key_filter
              self.last_tag_offset = 0

          def work(self, input_items, output_items):
              output_items[0][:] = input_items[0]

              tags = self.get_tags_in_window(0, 0, len(input_items[0]), pmt.intern(self.key_filter))
              for tag in tags:
                  delta_in_samps = tag.offset - self.last_tag_offset
                  self.add_item_tag(0, tag.offset, pmt.intern("delta"),\
                      pmt.from_long(delta_in_samps))
                  self.last_tag_offset = tag.offset
                  print(f"delta in offset (samples) : {delta_in_samps}")
                  samp_time = 1/585.97
                  ppm = (585.938/delta_in_samps)*60
                  print(f"PPM = {ppm}")
              return len(output_items[0])
    key_filter: '"index"'
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    comment: 600 kS/s -> 75 kS/s
    decim: '8'
    taps: firdes.low_pass(1,600e3,600e3/(2*8), 1000)
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    comment: 75 kS/s -> 9.375 kS/s
    decim: '8'
    taps: firdes.low_pass(1,75e3,75e3/(2*4), 1000)
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-800000'
    comment: 2.4 MS/s -> 600 kS/s
    decim: '4'
    samp_rate: samp_rate
    taps: firdes.low_pass(1,samp_rate,samp_rate/(2*4), 1000)
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    name: First output
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: Second time sink at end
    nconnections: '2'
    size: '1024'
    srate: '585.9375'
    type: float
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '16'
    interp: '1'
    type: fff
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: signal
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: file_cf32
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: signal
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    comment: |-
      Reduce the sample rate to make
      computation lighter and
      plots easier to see
    stream_id: file_cf32
  states: {}

connections:
- [analog_pll_refout_cc_0, '0', blocks_multiply_conjugate_cc_0, '1']
- [blocks_char_to_float_0, '0', epy_block_0, '0']
- [blocks_complex_to_mag_0, '0', rational_resampler_xxx_0, '0']
- [blocks_float_to_complex_0, '0', blocks_throttle_0, '0']
- [blocks_moving_average_xx_0, '0', blocks_complex_to_mag_0, '0']
- [blocks_multiply_conjugate_cc_0, '0', blocks_moving_average_xx_0, '0']
- [blocks_peak_detector2_fb_0, '0', blocks_char_to_float_0, '0']
- [blocks_throttle_0, '0', virtual_sink_1, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [blocks_wavfile_source_0, '1', blocks_float_to_complex_0, '1']
- [epy_block_0, '0', epy_block_1, '0']
- [epy_block_1, '0', qtgui_time_sink_x_2, '0']
- [fir_filter_xxx_0, '0', fir_filter_xxx_0_0, '0']
- [fir_filter_xxx_0_0, '0', qtgui_time_sink_x_1, '0']
- [fir_filter_xxx_0_0, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_0, '0', fir_filter_xxx_0, '0']
- [rational_resampler_xxx_0, '0', blocks_peak_detector2_fb_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_time_sink_x_2, '1']
- [virtual_source_0, '0', analog_pll_refout_cc_0, '0']
- [virtual_source_0, '0', blocks_multiply_conjugate_cc_0, '0']
- [virtual_source_1, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
